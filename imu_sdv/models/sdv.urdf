Commit message: new robot model

File: imu_sdv/models/sdv.urdf (robot description, URDF)
Before this commit: robot sdv, 1 links, 0 joints
Links:
- link base_link2: geometry visual mesh filename=package://imu_sdv/models/meshes/sdv.stl scale=0.001 0.001 0.001
